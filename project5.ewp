# IAR project project5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project5.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Embedded_Programming\Lesson13\STACK_NHEAP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: bsp.c delay.c fact.c main.c startuptm4c.c swap.c tm4c_cmsis.h
    ../../Embedded Lessons/modern-embedded-programming-course-main/lesson-12/CMSIS/Include/: core_cm4.h
    ../../ti/TivaWare_C_Series-2.2.0.295/inc/: tm4c123gh6pm.h
